# Keil uVision project AT89C51_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: AT89C51_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: NVA_NO_STDBOOL_H,NVA_NO_RESTRICT,NVA_NO_STRING_H,NVA_NO_LONG_LONG_TYPE,NVA_NO_INF_AND_NAN
  c include: .\inc;..\..\nva_print\inc;..\..\nva_print\decl_and_def;..\
  group main
    ./src/: main.c
  group nva_print
    ../../nva_print/src/: nva_print.c nva_stack.c nva_string.c nva_format.c
  group nva_mcu_test_suits
    ../: mcu_test_suits.c mcu_test_suits.h
